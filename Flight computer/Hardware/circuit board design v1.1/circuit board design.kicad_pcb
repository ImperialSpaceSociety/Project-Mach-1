# Repository ImperialSpaceSociety/Project-Mach-1 (continued)

## KiCad design Flight computer/Hardware/circuit board design/circuit board design.kicad_pcb (continued)

Board: 4 copper layers, 30.5 x 82.6 mm, 89 parts (4 on the bottom side), 70 nets.

Other parts of the board:
U7: W74M64FV; SOIC-8_5.23x5.23mm_P1.27mm

Their connections:
+3V3: U7.3, U7.7, U7.8; also elsewhere on the board
/MCU/MCU_MISO4: U7.2; also elsewhere on the board
/MCU/MCU_MOSI4: U7.5; also elsewhere on the board
/MCU/MCU_NSEL4: U7.1; also elsewhere on the board
/MCU/MCU_SCLK4: U7.6; also elsewhere on the board
GND: U7.4; also elsewhere on the board

## Code that names these connections

File Flight computer/Software/SAMD flight computer code/SAMD flight computer code/atmel_start_pins.h:

/*
 * Code generated from Atmel Start.
 *
 * This file will be overwritten when reconfiguring your Atmel Start project.
 * Please copy examples or other code you want to keep to a separate file
 * to avoid losing it when reconfiguring.
 */
#ifndef ATMEL_START_PINS_H_INCLUDED
#define ATMEL_START_PINS_H_INCLUDED

#include <hal_gpio.h>

// SAMD21 has 8 pin functions

#define GPIO_PIN_FUNCTION_A 0
#define GPIO_PIN_FUNCTION_B 1
#define GPIO_PIN_FUNCTION_C 2
#define GPIO_PIN_FUNCTION_D 3
#define GPIO_PIN_FUNCTION_E 4
#define GPIO_PIN_FUNCTION_F 5
#define GPIO_PIN_FUNCTION_G 6
#define GPIO_PIN_FUNCTION_H 7

#define PA08 GPIO(GPIO_PORTA, 8)
#define PA09 GPIO(GPIO_PORTA, 9)
#define PA16 GPIO(GPIO_PORTA, 16)
#define PA17 GPIO(GPIO_PORTA, 17)
#define PA22 GPIO(GPIO_PORTA, 22)
#define PA23 GPIO(GPIO_PORTA, 23)
#define PB00 GPIO(GPIO_PORTB, 0)
#define PB02 GPIO(GPIO_PORTB, 2)
#define PB03 GPIO(GPIO_PORTB, 3)
#define PB12 GPIO(GPIO_PORTB, 12)
#define PB13 GPIO(GPIO_PORTB, 13)
#define PB14 GPIO(GPIO_PORTB, 14)

#endif // ATMEL_START_PINS_H_INCLUDED

File Software/Arduino code/blink/blink.ino:

/*
  Blink for Flight Computer Turns LEDs alternatively on for one second, then off for one second, repeatedly. This example code is in the public domain. http://www.arduino.cc/en/Tutorial/Blink
*/

#ifndef PIN_LED_RED
#define PIN_LED_RED (38u)
#endif

#ifndef PIN_LED_BLUE
#define PIN_LED_BLUE (39u)
#endif

#ifndef PIN_BUZZER
#define PIN_BUZZER (0u)
#endif

// the setup function runs once when you press reset or power the board
void setup() {
  // initialize digital pins as output.
  pinMode(PIN_LED_RED, OUTPUT);
  pinMode(PIN_LED_BLUE, OUTPUT);
  pinMode(PIN_BUZZER, OUTPUT);

}

// the loop function runs over and over again forever
void loop() {
  digitalWrite(PIN_LED_RED, HIGH); // turn the LED on (HIGH is the voltage level)
  digitalWrite(PIN_LED_BLUE, LOW); // turn the LED off by making the voltage LOW
  tone(PIN_BUZZER, 1000); // Send 1KHz sound signal...
  
  delay(200); // wait for a second
  digitalWrite(PIN_LED_RED, LOW); // turn the LED off by making the voltage LOW
  digitalWrite(PIN_LED_BLUE, HIGH); // turn the LED on (HIGH is the voltage level)
  noTone(PIN_BUZZER);     // Stop sound...
  
  delay(500); // wait for half a second
}

## Commit log (part)

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2019-07-10 Update README.md
    Propose some structure for repository
2019-07-11 Create directory structure
2019-07-11 Link directories
2019-08-19 Simplified the structure
2019-08-19 added the right module names to readme
2019-08-19 added drawing of rocket
2019-08-23 Added documentation and also the references to all components
2019-08-24 Got the GPS wired up with the MAX-M8C.
    I wired up the MCU to the GPS as well. Sensors are also wired up to the I2C line.
    TODO:
    -make everything run on 3.3V
    - work out the pyro charges and drivers
    many more.
2019-08-24 Connected the SPI connection with the SIlabs radio and the XTAL
2019-08-31 Wired up the SI4463 according to AN628 figure 16. Component values have not been set. Only type of component.
2019-08-31 Swapped out the XTAL with a tcxo for radio.
2019-08-31 worked on the silabs 4463 radio chip
    - filled in the component values for TX matching and tx filtering
    - filled in tentative values for RX LNA matching. Will have to verify
    - swapped out XTAL and put in an RS Pro TCXO. Decoupled its powersupply.
2019-09-01 Change Tx Filter
2019-09-01 Radio Update
2019-09-02 added the library for the BMI088 to local directory
2019-09-02 changed all the paths for the schematic, footprints to local versions
    so that it will not break when others access from another computer
2019-09-02 changed the SPI flash chip
    -changed to Winbond W74M64FV 64Mbit flash chip to run on 3.3V. Changed schematic symbol and foot print.
    - changed the names of hierarchical labels for the pyros
2019-09-02 Wired the GYRO Ready and ACCL ready interrupt pins
2019-09-02 created net list for first time
    -changed SAML21 to J variant7
    -filled in foot prints for all components exept comparator
    -changed the footprints of ICSS pico tracker to a local copy
2019-09-04 more upgrades
    - removed the comparators
    - added the cost and link to buy components
    - added in a symbol for USB
2019-09-04 Wired up the FETs
    -fixed the ERC error for the BMI088 symbol
2019-09-04 connected 4 channels of pyro drivers
2019-09-04 put in the indicator LEDs
2019-09-04 removed the 37khz crystal
2019-09-04 swapped out the MCU from QFN to TQFP
    I suspect I will be making errors and almost certainly will have to jump wires. I think QFN is a nightmare to solder to.
2019-09-05 fixed errors with symbol and footprint connections
2019-09-05 added screw terminal symbols and anotated power supply page
2019-09-05 set up the PCB to fit formfactor
2019-09-05 Experimenting with arranging components on board. removed matching componets for GPS
2019-09-06 changed the footprint for 220 nH inductor and removed the circuit for low power voltage measurments
2019-09-06 removed the 100 ohm resistors on the gate of the pyro mosfets
2019-09-09 added in the foot prints for the 0433BM41A0019 integrated front end for SI4463
    U.FL_Hirose footprint and symbol added in for GPS active antenna
2019-09-09 added in the RF front end, exactly as stated in AN904
2019-09-09 put in a UFL connector in place of the Active GPS antenna
2019-09-09 added in some comments
2019-09-09 completed the pi circuit for Telemetry antenna
2019-09-09 changed the pin header to 2.54mm pitch for programmer and added a 3 pin header for antenna 434
2019-09-09 added pull down resistor to arm switch pin to prevent it from floating and accidentally fireing
2019-09-11 moved reset pin to programming pin header
2019-09-11 added in comment about where I got the ref layout for GPS+active antenna
2019-09-11 Added the USB protection IC
2019-09-12 added the arming switch. Changed foot print of lipo connector to JST
2019-09-12 updated the datasheet links and sites to purchase
2019-09-12 swapped out the 434 wire antenna for a Yageo434 chip antenna for smaller form factor
    I put in the 3D model for the te connectivity terminal blocks
2019-09-12 I put in a 4 terminal block for arming switch
2019-09-13 put in the Yageo 434 antenna
2019-09-13 Did Major reworking of ports
2019-09-13 added in the footprint for the 6 terminal block
    routed the RF section with the 434 antenna
2019-09-14 Done extensive routing of the board.
2019-09-15 only 2 or 3 connections left to route
2019-09-15 All connections routed!!
2019-09-16 Put in the Code for the flight computer and drivers.
2019-09-16 added in molex usb 3D cad and silk screen ICSS logo
2019-09-16 added links for purchasing some of the parts
2019-09-16 Precisely aligned the mounting holes
2019-09-16 done for today
2019-09-17 added in crystal footprint
2019-09-17 Finished routing the board with 3.3V power plane
    Power for mosfets comes from 2mm tracks on top layer. Todo: make their connection to ground more robust
2019-09-17 updated some of the purchase links
2019-09-17 added in copper pour to top and bottom layer. Change SPI flash chip
2019-09-18 forced to commit
2019-09-18 test
2019-09-18 remove merging conflicts
2019-09-18 changed SPI flash chip
2019-09-18 Flood fill top and bottom layer
2019-09-18 added in excel bill of material. Swapped out SAML for SAMD. They are pin compatible
2019-09-22 made a new folder for flight computer v1.1 for the 38mm size minimum diameter rockets
2019-09-23 put in new acclerometers and 9dof sensor. Changed supplier from mouser to farnell and RS
2019-09-23 Fully routed board v1.1 with the new high g accelerometer
2019-09-23 flood fill top and bottom layers
2019-09-24 put in logo for V1.1
2019-09-24 changed GPS to M8Q and included the diode from V bus to foot print which I missed out
2019-09-24 added in grove connector for break out pins. Made a new software framework for SAMD
2019-09-24 added 3d model of grove connnector
2019-09-25 sent for pcb manufacturing
2019-09-27 added in renders of the flight computer
2019-10-01 updated links to purchase
2019-10-11 put in the last bom purchase links
2019-11-07 put in blink software
2019-11-08 put in code
2020-01-21 added in arduino code and board files
2020-01-22 added in variants for rocket flight computer
2020-01-23 put in some working arduino c files. updated variant.cpp and variant.h.
    I2C and GPS still not working
2020-02-06 Got i2c working with changes to variant.cpp and variant.h
2020-02-13 removed unecessary board files
2020-02-18 Put in main flight computer code folder
2020-02-18 put in code for the h3Lis100 into main
2020-02-20 made main code work
2020-02-20 changed spi pin adresses and pads on the bottom of file
2020-02-20 9-degree acc added
2020-02-20 corrected PAD_SPI_TX and PAD_SPI_RX to the correct ones
2020-02-21 added in flash diagonostics with correct chip select pin defined
2020-02-26 First comit on new branch
    Changed variant files to be more specific to flight computer. Less general purpose Arduino and focuseed on actual hardware. Checked both USb and GPS serial and both wire interfaces.
    ** Note pin numbers have changed**
2020-02-27 Fixed SPI definitions in Variant.h
    Corrected conflicting and multiple definitions for SPI in varaint.c. Not tested though
2020-10-23 move all atmel studio projects into single folder
2020-10-23 put in dependency libraries for adafruit libraries
2020-10-27 put in printout of info in main program
2020-10-27 update flash chip in BOM
2020-10-27 updated ports info
2020-11-10 fixed the computer pin
2020-11-10 Implement a function to sample the GPS/GNSS sensor
2020-11-10 Remove unnecessary ==
2020-11-10 removed uncessary import of SPI
2020-12-01 Added blinking lights when landed
2020-12-01 adding the data packets, read and print functions
2021-02-09 adding write functionality to flash memory, writes contiguous stream to memory
2021-02-16 added stop after n seconds functionality, test results before run, and erase chip option
2021-02-16 radio send commands
    fixed sending of gps data in one pulse and added a simple send commands through terminal
2021-02-16 use neater declaration
2021-02-16 fix bug with referencing pointer
2021-02-16 Send Radio transmission every 10ms
2021-02-16 update comment
2021-02-16 send data only if gnd station mode
2021-02-16 remove duplicated library files
    It is already in the directory of the main_flight_computer_code
2021-02-16 return import back to original method
2021-02-16 put instructions for installing the library files for radio
2021-02-23 Put in rocket flight computer modes documentation
2021-02-25 Update variant.cpp
    Corrected pin mapping and ADC channels, all three ADC pins work.
2021-02-25 Battery level reading
    Created a function reading the voltage level, it also calculates percentage of the battery given min and max voltages
2021-06-17 make blink agnostic of the correct board files
2021-06-17 put in platform io and blinky
2021-06-17 switch to the J variant
2021-06-17 set correct variant
2021-06-17 put in variant files for the rocket flight computer board.
    Platform io will look for this custom files. Importantly, it tracks the variants in version control, and is sharable.
2021-06-18 move variants files into the boards folder
2021-06-18 add library dependencies
2021-06-18 put in main code
2021-06-18 auto format
2021-06-18 format and import
2021-06-18 adapt to multi file
2021-06-18 compiles
2021-06-18 make it compile the gps tasks as well
2021-06-18 reorganise repo to reduce file name length
    Windows complains that the filename lengths become too long
2021-06-18 Send message to ublox only after initialising.
2021-06-18 organise
2021-06-18 organise better
2021-06-18 use standarised naming
2021-06-18 print format
2021-06-18 put in rtos version
2021-06-18 move user commands to another file
2021-06-18 run diagnositcs first
2021-06-19 use channel 0
2021-06-19 set packet size to 64 bytes
2021-06-21 put in A repeated at 8 times speed
2021-06-21 use #define for our char
2021-06-21 sends out "f" ascii, as intended sometimes
2021-06-21 put big b
2021-06-21 run high speed f
2021-06-21 simplified f
2021-06-21 add in buzzer
2021-06-21 downgrade spi memory lib to v3.3
    fixes #16
2021-06-21 switch to using github package
2021-06-21 update to repo with right i2c address
2021-06-22 create sdfat_format
2021-06-22 fixed issue with rubbish data from ms5607
    fixes #19
2021-06-22 specify the silabs pins for our board
    fixes #20
2021-06-23 use file system
2021-06-23 put in examples of file system
2021-06-23 don't do full test run
2021-06-24 remove old flash functions
2021-06-24 adapt file system files
2021-06-24 increase sensor thread memory
2021-06-24 use our file inplementation
2021-06-24 remove spi memory
2021-06-24 use pointer to file
2021-06-24 use long form method for saving to flash
2021-06-25 add in working 2 way comms
2021-06-25 send data over radio
2021-06-25 temporarily disable flash and sensors
2021-06-25 allow sensor read
2021-06-25 printout out percentage and voltage
2021-06-25 move code folder to make filepaths shorter
2021-06-25 shorter name for folder
2021-06-25 revert back to using default libraries
    Or the device hangs.
2021-06-25 remove all flash code
2021-06-25 put in flash code
2021-06-25 log custom datastruct
2021-06-26 use adafruit spiflash for datastorage
2021-06-26 don't put into RX mode
    because the program in the library uses delay microseconds to wait for RX. Holds up every other thread when using delay microseconds
2021-06-26 no whiles
2021-06-26 save datapacket
2021-06-26 use vtaskdelay
    Immediately, processor utilisation falls from 50% to 1%
2021-06-26 print debug
2021-06-26 log timestamp
2021-06-26 access datapacket from outside
2021-06-26 fix bug in sending
2021-06-26 make more readable
2021-06-26 lat before long
2021-06-26 make datapacket more efficient
2021-06-26 flush instead of close
2021-06-26 sample every 50 ms
2021-06-26 goldilocks priorities
2021-06-26 dont use delay
2021-10-04 put in flash dumper
2021-10-04 put in flash chip deleter
2021-11-19 Created text files for ideas
    Put your ideas in relevant text files
2021-11-19 new sensors added
2021-11-26 pyro_driver
2021-11-27 Moved to proper folder
2021-12-02 added radio links
2021-12-03 Update and rename Radio ideas.txt to Radio ideas.md
    Added SX1278 and RFM95 radios
2021-12-06 eagle_power_supply
2021-12-09 Added component
2021-12-09 Pressure sensor additions
2022-01-15 Added sensors schematic and updated pyro_driver schematic
    Added the external libraries used for the components as well. Everything is saved under Project-Mach-1\Hardware\circuit board design v1.1\Eagle versions
2022-02-04 Added sensor schematic and updated pyro driver schematic
