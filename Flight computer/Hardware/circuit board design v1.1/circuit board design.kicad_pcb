# Repository ImperialSpaceSociety/Project-Mach-1 (continued)

## KiCad design Flight computer/Hardware/circuit board design v1.1/circuit board design.kicad_pcb (continued)

Board: 4 copper layers, 30.5 x 82.6 mm, 86 parts (4 on the bottom side), 69 nets.

Other parts of the board:
J5: Conn_01x04; NS-Tech_Grove_1x04_P2mm_Vertical
U4: MAX-M8Q; ublox_MAX

Their connections:
+3V3: J5.3, U4.6, U4.7, U4.8; also elsewhere on the board
/MCU/GPS_RXD0: U4.2; also elsewhere on the board
/MCU/SCL_PA09: J5.1; also elsewhere on the board
/MCU/SDA_PA08: J5.2; also elsewhere on the board
/gps/GPS_1PPS: U4.4; also elsewhere on the board
/gps/GPS_NRES: U4.9; also elsewhere on the board
/gps/GPS_NSAFEBOOT: U4.18; also elsewhere on the board
/gps/GPS_RXD: U4.3; also elsewhere on the board
/gps/GPS_SCL: U4.17; also elsewhere on the board
/gps/GPS_SDA: U4.16; also elsewhere on the board
GND: J5.4, U4.1, U4.10, U4.12; also elsewhere on the board
unnamed 63: U4.11; also elsewhere on the board
unnamed 66: U4.14; also elsewhere on the board

File Flight computer/Hardware/circuit board design v1.1/BOM updated.xlsx:

Bill of materials for Project Mach 1, the high powered rocketry project at the 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
The flight computer has a size of
Components that go on the PCB
Reference | Value | Footprint | Datasheet | Unit cost | Purchase Link | Quantity per flight computer
ANT1 | Yageo434 | flight-computer:Yageo434 | https://www.mouser.co.uk/datasheet/2/447/An_SMD_UHF_433_1204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 | 1.33 | https://www.mouser.co.uk/ProductDetail/Yageo/ANT1204F002R043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 | 1
BZ1 | Buzzer | Buzzer_Beeper:Buzzer_12x9.5RM7.6 | https://docs-emea.rs-online.com/webdocs/1581/0900766b815810c5.pdf | 1.05 | https://uk.rs-online.com/web/p/magnetic-buzzer-components/61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 | 1
> C8, C20, C34 | 10nF | Capacitor_SMD:C_0402_1005Metric | ~ |  |  | 3
C9 | 270pF | Capacitor_SMD:C_0402_1005Metric | ~ |  |  | 1
C19 | 270pf | Capacitor_SMD:C_0402_1005Metric | ~ |  |  | 1
C21 | 33nF | Capacitor_SMD:C_0402_1005Metric | ~ |  |  | 1
> C22, C35, C36, C90 | 1uF | Capacitor_SMD:C_0603_1608Metric | ~ |  |  | 4
> C30, C77 | 220nF | Capacitor_SMD:C_0603_1608Metric | ~ |  |  | 2
> C1, C2, C5, C12, C32, C92 | 10uF | Capacitor_SMD:C_0603_1608Metric | ~ |  |  | 6
> C3, C4, C6, C7, C11, C23, C28, C29, C31, C33, C89, C91, C93 | 100nF | Capacitor_SMD:C_0603_1608Metric | ~ |  |  | 13
> C86, C88 | 15pF | Capacitor_SMD:C_0402_1005Metric | ~ |  |  | 2
D1 | RED_LED | LED_SMD:LED_0603_1608Metric | ~ |  |  | 1
D2 | BLUE_LED | LED_SMD:LED_0603_1608Metric | ~ |  |  | 1
D3 | DFLS130L | Diode_SMD:D_PowerDI-123 | https://www.diodes.com/assets/Datasheets/ds30492.pdf | 0.45 | https://www.mouser.co.uk/ProductDetail/Diodes-Incorporated/D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 | 1
> H1-H4 | MountingHole_Pad | MountingHole:MountingHole_3.2mm_M3_Pad | ~ |  |  | 4
J1 | Conn_01x05 | Connector_PinHeader_2.54mm:PinHeader_1x05_P2.54mm_Vertical | ~ |  |  | 1
J2 | USB_B_Micro | flight-computer:USB_Micro-B_Molex-105017-0001 | https://www.molex.com/webdocs/datasheets/pdf/en-us/105017000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 | 0.63900000000000001 | https://www.mouser.co.uk/ProductDetail/Molex/105017-0001?qs=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 | 1
> J3, J5 | Screw_Terminal_01x04 | flight-computer:TerminalBlock_TE_282834-4_1x04_P2.54mm_Horizontal | ~ |  | https://www.mouser.co.uk/ProductDetail/TE-Connectivity/28283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 | 2
J4 | Conn_01x02 | Connector_JST:JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical | https://docs-emea.rs-online.com/webdocs/1347/0900766b81347511.pdf | 0.38 | https://uk.rs-online.com/web/p/pcb-headers/8201422/ | 1
> J6, J7 | Conn_Coaxial | Connector_Coaxial:U.FL_Hirose_U.FL-R-SMT-1_Vertical | https://www.mouser.co.uk/datasheet/2/185/U.FL_catalog-939761.pdf | 1.05 | https://www.mouser.co.uk/ProductDetail/Hirose-Connector/UFL-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 | 2
L1 | L_Core_Ferrite | Inductor_SMD:L_0603_1608Metric | ~ |  |  | 1
L2 | 27nH | Resistor_SMD:R_0402_1005Metric | ~ |  |  | 1
L3 | 0R | Inductor_SMD:L_0402_1005Metric | ~ |  |  | 1
L8 | 220nH | Inductor_SMD:L_0603_1608Metric | ~ |  |  | 1
R2 | 10 Ohm | Resistor_SMD:R_0402_1005Metric | ~ |  |  | 1
> C10, R7 | NF | ... | ~ |  |  | 2
> R1, R12, R25, R26 | 1K | Resistor_SMD:R_0603_1608Metric | ~ |  |  | 4
> R3, R13, R17, R18 | 3.3K | Resistor_SMD:R_0603_1608Metric | ~ |  |  | 4
> R6, R16, R23, R24 | 27K | Resistor_SMD:R_0603_1608Metric | ~ |  |  | 4
> R5, R15, R21, R22, R28, R29 | 100K | Resistor_SMD:R_0603_1608Metric | ~ |  |  | 6
U1 | IIS2MDC | Package_LGA:LGA-12_2x2mm_P0.5mm | https://www.mouser.co.uk/datasheet/2/389/iis2mdc-1309412.pdf | 1.93 | https://www.mouser.co.uk/ProductDetail/STMicroelectronics/II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 | 1
U2 | 0433BM41A0019E | Johanson_frontend:BALUN_0433BM41A0019E | https://www.johansontechnology.com/datasheets/0433BM41A0019/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 | 0.745 | https://www.mouser.co.uk/ProductDetail/Johanson-Technology/0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 | 1
U3 | Si4463 | Package_DFN_QFN:QFN-20-1EP_4x4mm_P0.5mm_EP2.6x2.6mm_ThermalVias | https://www.silabs.com/documents/public/data-sheets/Si4464-6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 | 2.2799999999999998 | https://www.mouser.co.uk/ProductDetail/Silicon-Labs/SI4463-C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 | 1
U4 | MAX-M8C | RF_GPS:ublox_MAX | https://www.u-blox.com/sites/default/files/MAX-M8-FW3_DataSh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 | 11.99 | https://store.uputronics.com/index.php?route=product/product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 | 1
> U5, U6 | Si7232DN | Package_SO:Vishay_PowerPAK_1212-8_Dual | https://www.vishay.com/docs/68986/si7232dn.pdf | 0.72899999999999998 | https://www.mouser.co.uk/ProductDetail/Vishay-Siliconix/SI72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 | 2
U8 | MS5607-02BA | Package_LGA:LGA-8_3x5mm_P1.25mm | https://www.te.com/commerce/DocumentDelivery/DDEController?A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 | 2.42 | https://www.mouser.co.uk/ProductDetail/Measurement-Specialti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 | 1
U9 | STF202-22T1G | Package_SO:TSOP-6_1.65x3.05mm_P0.95mm | https://www.onsemi.com/pub/Collateral/STF202-22T1-D.PDF | 0.46700000000000003 | https://www.mouser.co.uk/ProductDetail/ON-Semiconductor/STF2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 | 1
U10 | BMI088 | BMI088:PQFN50P450X300X100-16N | https://ae-bst.resource.bosch.com/media/_tech/media/datashee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 | 5.21 | https://www.mouser.co.uk/ProductDetail/Bosch-Sensortec/BMI08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 | 1
U11 | ATSAML21J18B-AUT | Package_QFP:TQFP-64_10x10mm_P0.5mm | http://ww1.microchip.com/downloads/en/DeviceDoc/60001477A.pdf | 4.1500000000000004 | https://www.mouser.co.uk/ProductDetail/Microchip-Technology/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 | 1
U14 | MAX40200AUK | Package_TO_SOT_SMD:SOT-23-5 | https://datasheets.maximintegrated.com/en/ds/MAX40200.pdf | 0.72899999999999998 | https://www.mouser.co.uk/ProductDetail/Maxim-Integrated/MAX4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 | 1
U15 | LD3985G33R_TSOT23 | Package_TO_SOT_SMD:TSOT-23-5 | http://www.st.com/internet/com/TECHNICAL_RESOURCES/TECHNICAL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 | 0.48299999999999998 | https://www.mouser.co.uk/ProductDetail/STMicroelectronics/LD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 | 1
U? | W25Q64JVSSIM | Package_SO:SOIC-8_5.23x5.23mm_P1.27mm | https://docs-emea.rs-online.com/webdocs/1703/0900766b81703f87.pdf | 0.71799999999999997 | https://uk.rs-online.com/web/p/flash-memory/1882666/ | 1
X1 | TM-32.000-AF3-33-S-Oscillator | Crystal:Crystal_SMD_2520-4Pin_2.5x2.0mm | https://docs-emea.rs-online.com/webdocs/15dc/0900766b815dc7d9.pdf | 3.43 | https://uk.rs-online.com/web/p/tcxo-oscillators/1442366/ | 1
Y3 | 16MHz | flight-computer:Crystal_SMD_2520-4Pin_2.5x2.0mm | https://docs-emea.rs-online.com/webdocs/15dc/0900766b815dc75d.pdf | 0.65100000000000002 | https://uk.rs-online.com/web/p/crystal-units/1442292/ | 1
External components
Active GPS antenna | 2066400001 |  | https://www.mouser.co.uk/datasheet/2/276/2066400001_ANTENNAS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 | 5.3 | https://www.mouser.co.uk/ProductDetail/Molex/206640-0001?qs=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 | 1
Fixed costs(one off purchase)
Item | Part number | Description |  | Unit cost | Purchase link | Quantity needed
Custom Printed Circuit Board |  | custom circuit boards and stensils |  | 48.8 | https://jlcpcb.com/quote#/?orderType=1&stencilWidth=30.48&st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 | 1
SEGGER J-Link EDU Debugging Emulator | 131-1323 | programmer for microcontrollers |  | 62.68 | https://uk.rs-online.com/web/p/products/1311323 | 1
Mouser delivery |  | Delivery cost for mouser components |  | 12
Total costs
 |  | There will be 5 flight computers built because the minimum order for PCBs is 5.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
 |  | I also include the one time cost of making the PCBs and the programmer
 |  | Total cost: | 452
 |  |  |  |  |  |  | 26.5
 |  |  |  |  |  |  | 26.5
 |  |  |  |  |  |  | 75.3

## KiCad design Flight computer/Hardware/circuit board design/circuit board design.kicad_pcb

Parts:
C28, C29, C31, C33: 100nF; C_0402_1005Metric
C30, C77: 220nF; C_0402_1005Metric
C32: 10uF; C_0402_1005Metric
U1: IIS2MDC; LGA-12_2x2mm_P0.5mm
U8: MS5607-02BA; LGA-8_3x5mm_P1.25mm
U10: BMI088; PQFN50P450X300X100-16N

Connections:
+3V3: C28.1, C29.1, C31.2, C32.2, C33.2, C77.1, U1.3 (CS), U1.9 (Vdd), U1.10 (Vdd_IO), U8.1 (VDD), U8.2 (PS), U10.3 (VDD), U10.7 (PS), U10.11 (VDDIO), U10.14 (CSB1); also elsewhere on the board
/gps/GPS_SCL: U1.1 (SCL), U8.8 (SCLK), U10.8 (SCL/SCK); also elsewhere on the board
/gps/GPS_SDA: U1.4 (SDA), U8.7 (SDI/SDA), U10.9 (SDA/SDI); also elsewhere on the board
/sensors/ACCL_RDY: U10.16 (INT1); also elsewhere on the board
/sensors/GYRO_RDY: U10.12 (INT3); also elsewhere on the board
/sensors/MAG_RDY: U1.7 (INT/DRDY); also elsewhere on the board
GND: C28.2, C29.2, C30.2, C31.1, C32.1, C33.1, C77.2, U1.6 (GND), U1.8 (GND), U8.3 (GND), U8.4 (CSB), U8.5 (CSB), U10.4 (GNDA), U10.6 (GNDIO), U10.10 (SDO2), U10.15 (SDO1); also elsewhere on the board
unnamed: C30.1, U1.5 (C1)

Notes on the sheet:
Power supply decoupling capacitors (100 nF ceramic, 10 μF aluminum)

Parts:
C8: 10nF; C_0402_1005Metric
C11: 100nF; C_0603_1608Metric
C12: 10uF; C_0603_1608Metric
J6: Conn_Coaxial; U.FL_Hirose_U.FL-R-SMT-1_Vertical
L2: 27nH; R_0402_1005Metric
R2: 10 Ohm; R_0402_1005Metric
U4: MAX-M8C; ublox_MAX

Connections:
+3V3: C11.1, C12.1, U4.6 (V_BCKP), U4.7 (VCC_IO), U4.8 (VCC); also elsewhere on the board
/MCU/GPS_RXD0: U4.2 (TXD); also elsewhere on the board
/gps/GPS_1PPS: U4.4 (TIMEPULSE); also elsewhere on the board
/gps/GPS_NRES: U4.9 (~RESET); also elsewhere on the board
/gps/GPS_NSAFEBOOT: U4.18 (~SAFEBOOT); also elsewhere on the board
/gps/GPS_RXD: U4.3 (RXD); also elsewhere on the board
/gps/GPS_SCL: U4.17 (SCL); also elsewhere on the board
/gps/GPS_SDA: U4.16 (SDA); also elsewhere on the board
GND: C8.2, C11.2, C12.2, J6.2 (Ext), U4.1 (GND), U4.10 (GND), U4.12 (GND); also elsewhere on the board
unnamed: C8.1, L2.1, R2.1
unnamed: J6.1 (In), L2.2, U4.11 (RF_IN)
unnamed: R2.2, U4.14 (VCC_RF)

Notes on the sheet:
http://www.explorelabs.com/blog/designing-a-gps-receiver/#ref-ublox-datasheet Important info on why we use the components
Connected to active antenna, likely 2066400001 Molex active antenna. UFL connector
Layout according to MAX-8 / MAX-M8, Hardware Integration Manual, Section 2.4.2 Antenna design with active antenna.

Parts:
ANT1: Yageo434
C9: 270pF; C_0402_1005Metric
C10: NF; C_0402_1005Metric
C19: 270pf; C_0402_1005Metric
C20: 10nF; C_0402_1005Metric
C21: 33nF; C_0402_1005Metric
C22: 1uF; C_0603_1608Metric
C23: 100nF; C_0603_1608Metric
J7: Conn_Coaxial; U.FL_Hirose_U.FL-R-SMT-1_Vertical
L3: 0R; L_0402_1005Metric
L8: 220nH; L_0603_1608Metric
R7: NF; R_0402_1005Metric
U2: 0433BM41A0019E; BALUN_0433BM41A0019E
U3: Si4463; QFN-20-1EP_4x4mm_P0.5mm_EP2.6x2.6mm_ThermalVias
X1: TM-32.000-AF3-33-S-Oscillator; Crystal_SMD_2520-4Pin_2.5x2.0mm

Connections:
+3V3: C19.1, C21.2, C22.1, C23.1, L8.2, U3.6 (VDD), U3.8 (VDD), X1.4 (Vcc); also elsewhere on the board
/MCU/MCU_MISO1: U3.13 (SDO); also elsewhere on the board
/MCU/MCU_MOSI1: U3.14 (SDI); also elsewhere on the board
/MCU/MCU_NSEL1: U3.15 (~SEL); also elsewhere on the board
/MCU/MCU_PA12: U3.10 (GPIO1); also elsewhere on the board
/MCU/MCU_PA13: U3.9 (GPIO0); also elsewhere on the board
/MCU/MCU_PB10: U3.11 (~IRQ); also elsewhere on the board
/MCU/MCU_PB11: U3.1 (SDN); also elsewhere on the board
/MCU/MCU_SCLK1: U3.12 (SCLK); also elsewhere on the board
GND: C10.2, C19.2, C21.1, C22.2, C23.2, J7.2 (Ext), U2.1 (GND), U2.3 (GND), U2.4 (GND), U2.5 (GND), U3.18 (GND), U3.21 (GND), X1.2 (GND); also elsewhere on the board
unnamed: ANT1.1 (RF_IN), C10.1, L3.1
unnamed: C9.1, L3.2, R7.1
unnamed: C9.2, U2.2 (ANT)
unnamed: C20.1, U3.17 (XIN)
unnamed: C20.2, X1.3 (OUT)
unnamed: J7.1 (In), R7.2
unnamed: L8.1, U2.6 (TX), U3.4 (TX)
unnamed: U2.7 (RXN), U3.3 (RXn)
unnamed: U2.8 (RXP), U3.2 (RXp)

Notes on the sheet:
TX Bias
Arranged according to Silabs AN904
Antenna matching options

Parts:
C34: 10nF; C_0402_1005Metric
C35, C36: 1uF; C_0603_1608Metric
D3: DFLS130L; D_PowerDI-123
J2: USB_B_Micro; USB_Micro-B_Molex-105017-0001
J4: Conn_01x02; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
R28, R29: 100K; R_0603_1608Metric
U9: STF202-22T1G; TSOP-6_1.65x3.05mm_P0.95mm
U14: MAX40200AUK; SOT-23-5
U15: LD3985G33R_TSOT23; TSOT-23-5

Connections:
+3V3: C36.1, U15.5 (VOUT); also elsewhere on the board
/MCU/MCU_PB08: R28.2, R29.1; also elsewhere on the board
/MCU/USB_DM: U9.3 (D(IN)); also elsewhere on the board
/power_supply/USB_DM: U9.2 (D(IN)); also elsewhere on the board
GND: C34.2, C35.2, C36.2, J2.5 (GND), J2.6 (Shield), J4.2, R29.2, U9.6 (GND), U14.2 (GND), U15.2 (GND); also elsewhere on the board
unnamed: C34.1, U15.4 (BYP)
unnamed: C35.1, D3.1 (K), U14.5 (OUT), U15.1 (VIN), U15.3 (INH)
unnamed: J2.2 (D-), U9.5 (D(OUT))
unnamed: J2.3 (D+), U9.4 (D(OUT))
VBUS: D3.2 (A), J2.1 (VBUS), U9.1 (VBUS)
Vdrive: J4.1, R28.1, U14.1 (VDD), U14.3 (EN); also elsewhere on the board

Notes on the sheet:
1A Ideal Diode with Ultra-Low Voltage Drop. 43mV drop at 500mA draw
May have to increase the smoothing caps to 10uF for stronger effect.
3.6V-4.2V Li-po input. Needs to be regulated down to 3.3V cmos
Ultra low drop out voltage regulator. 140mV drop at max current of 150mA.
The maximum possible voltage drop(from 3.6V input) due to diode and LDO regulator is 173mV, leaving plenty of leeway to bring it down to 3.3V CMOS level.

Parts:
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C1, C2, C5, C92: 10uF; C_0603_1608Metric
C3, C4, C6, C7, C89, C91, C93: 100nF; C_0603_1608Metric
C86, C88: 15pF; C_0402_1005Metric
C90: 1uF; C_0603_1608Metric
D1: RED_LED; LED_0603_1608Metric
D2: BLUE_LED; LED_0603_1608Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J1: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
L1: L_Core_Ferrite; L_0603_1608Metric
R1, R12, R25, R26: 1K; R_0603_1608Metric
U11: ATSAML21J18B-AUT; TQFP-64_10x10mm_P0.5mm
Y3: 16MHz; Crystal_SMD_2520-4Pin_2.5x2.0mm

Connections:
+3V3: C1.1, C3.1, C5.1, C6.1, C7.1, C92.1, C93.1, J1.3, L1.1, R1.1, R12.1, U11.21 (VDDIO), U11.34 (VDDIO), U11.48 (VDDIO), U11.56 (VDDIN); also elsewhere on the board
/MCU/BUZZER: BZ1.1 (-), U11.1 (PA00)
/MCU/GPS_RXD0: U11.36 (PA17); also elsewhere on the board
/MCU/LED_BLUE: R26.2, U11.50 (PB23)
/MCU/LED_RED: R25.2, U11.49 (PB22)
/MCU/MCU_MISO1: U11.27 (PB14); also elsewhere on the board
/MCU/MCU_MISO4: U11.61 (PB00); also elsewhere on the board
/MCU/MCU_MOSI1: U11.25 (PB12); also elsewhere on the board
/MCU/MCU_MOSI4: U11.63 (PB02); also elsewhere on the board
/MCU/MCU_NSEL1: U11.28 (PB15); also elsewhere on the board
/MCU/MCU_NSEL4: U11.62 (PB01); also elsewhere on the board
/MCU/MCU_PA04: U11.13 (PA04); also elsewhere on the board
/MCU/MCU_PA05: U11.14 (PA05); also elsewhere on the board
/MCU/MCU_PA06: U11.15 (PA06); also elsewhere on the board
/MCU/MCU_PA07: U11.16 (PA07); also elsewhere on the board
/MCU/MCU_PA12: U11.29 (PA12); also elsewhere on the board
/MCU/MCU_PA13: U11.30 (PA13); also elsewhere on the board
/MCU/MCU_PB08: U11.11 (PB08); also elsewhere on the board
/MCU/MCU_PB10: U11.23 (PB10); also elsewhere on the board
/MCU/MCU_PB11: U11.24 (PB11); also elsewhere on the board
/MCU/MCU_SCLK1: U11.26 (PB13); also elsewhere on the board
/MCU/MCU_SCLK4: U11.64 (PB03); also elsewhere on the board
/MCU/SWCLK: J1.1, R1.2, U11.57 (PA30)
/MCU/SWDIO: J1.2, U11.58 (PA31)
/MCU/USB_DM: U11.45 (PA24); also elsewhere on the board
/MCU/XIN: C86.1, U11.31 (PA14), Y3.1
/MCU/XOUT: C88.1, U11.32 (PA15), Y3.3
/gps/GPS_1PPS: U11.3 (PA02); also elsewhere on the board
/gps/GPS_NRES: U11.4 (PA03); also elsewhere on the board
/gps/GPS_NSAFEBOOT: U11.2 (PA01); also elsewhere on the board
/gps/GPS_RXD: U11.35 (PA16); also elsewhere on the board
/gps/GPS_SCL: U11.44 (PA23); also elsewhere on the board
/gps/GPS_SDA: U11.43 (PA22); also elsewhere on the board
/power_supply/USB_DM: U11.46 (PA25); also elsewhere on the board
/pyro_driver/FIRE_A: U11.19 (PA10); also elsewhere on the board
/pyro_driver/FIRE_B: U11.20 (PA11); also elsewhere on the board
/pyro_driver/FIRE_C: U11.17 (PA08); also elsewhere on the board
/pyro_driver/FIRE_D: U11.18 (PA09); also elsewhere on the board
/sensors/ACCL_RDY: U11.41 (PA20); also elsewhere on the board
/sensors/GYRO_RDY: U11.42 (PA21); also elsewhere on the board
/sensors/MAG_RDY: U11.40 (PB17); also elsewhere on the board
GND: BZ1.2 (+), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C86.2, C88.2, C89.2, C90.2, C91.2, C92.2, C93.2, D1.1 (K), D2.1 (K), H1.1, H2.1, H3.1, H4.1, J1.4, U11.7 (GNDANA), U11.22 (GND), U11.33 (GND), U11.47 (GND), U11.54 (GND), Y3.2, Y3.4; also elsewhere on the board
unnamed: C2.1, C4.1, L1.2, U11.8 (VDDANA)
unnamed: C89.1, J1.5, R12.2, U11.52 (~RESET)
unnamed: C90.1, C91.1, U11.53 (VDDCORE)
unnamed: D1.2 (A), R25.1
unnamed: D2.2 (A), R26.1

Notes on the sheet:
Programming interface
SPI flash chip
Buzzer
Two indicator LEDs
Mechanical mounting holes

Parts:
J3, J5: Screw_Terminal_01x04; TerminalBlock_TE_282834-4_1x04_P2.54mm_Horizontal
R3, R13, R17, R18: 3.3K; R_0603_1608Metric
R5, R15, R21, R22: 100K; R_0603_1608Metric
R6, R16, R23, R24: 27K; R_0603_1608Metric
U5, U6: Si7232DN; Vishay_PowerPAK_1212-8_Dual

Connections:
/MCU/MCU_PA04: R5.1, R6.1; also elsewhere on the board
/MCU/MCU_PA05: R15.1, R16.1; also elsewhere on the board
/MCU/MCU_PA06: R21.1, R23.1; also elsewhere on the board
/MCU/MCU_PA07: R22.1, R24.1; also elsewhere on the board
/pyro_driver/FET_A: J3.4, R5.2, U6.6 (D1)
/pyro_driver/FET_B: J3.2, R15.2, U6.5 (D2)
/pyro_driver/FET_C: J5.4, R21.2, U5.6 (D1)
/pyro_driver/FET_D: J5.2, R22.2, U5.5 (D2)
/pyro_driver/FIRE_A: R3.1, U6.2 (G1); also elsewhere on the board
/pyro_driver/FIRE_B: R13.1, U6.4 (G2); also elsewhere on the board
/pyro_driver/FIRE_C: R17.1, U5.2 (G1); also elsewhere on the board
/pyro_driver/FIRE_D: R18.1, U5.4 (G2); also elsewhere on the board
GND: R3.2, R6.2, R13.2, R16.2, R17.2, R18.2, R23.2, R24.2, U5.1 (S1), U5.3 (S2), U6.1 (S1), U6.3 (S2); also elsewhere on the board
Vdrive: J3.1, J3.3, J5.1, J5.3; also elsewhere on the board

Notes on the sheet:
Goes to a Double Pole Single Throw switch
