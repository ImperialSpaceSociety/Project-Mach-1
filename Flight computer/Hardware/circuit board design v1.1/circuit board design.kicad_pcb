# Repository ImperialSpaceSociety/Project-Mach-1

File README.md:

# Project-Mach-1
This repository contains information to support the high powered rocketry project at the Imperial College Space Society. It documents the electronic Command and Control Modules which are used within the project.

## Repository Structure
The repository structure is based on the high level electronics modules:

* [Flight Computer](https://github.com/ImperialSpaceSociety/Project-Mach-1/blob/master/Flight%20computer)
* [docs - Top Level Specfications and Documents](https://github.com/ImperialSpaceSociety/Project-Mach-1/blob/master/docs)

Each Module description has the following structure:

* ICSS Specifications
* External specifications, references and documentation
* Electronic Hardware (schematics and PCB)
* Firmware
* Physical Hardware (CAD)

## Quick Reference
The following is intended to provide a view for the casual browser of the project content.

* The [Flight Computer](https://github.com/ImperialSpaceSociety/Project-Mach-1/blob/master/Flight%20computer) has these key role:
  * Unambiguously capture flight data for subsequent analysis
  * Verify and prove performance record data ( Mach)
  * Support it's own successful recovery

## Rocket flight computer requirements:
* flexible for two stage or one stage rocket
* must have buzzer
* must have flashing LEDs to help with recovery on the ground
* must have usb programmer and possibly for accessing stored data
* 3 mosfets for rocket trigger, parachute triggering, spare
* rocket to ground telemetry link
* GPS for tracking and recovery
* runs at 3.3V logic levels(CMOS)
* 9 dof acclermoeter, gyroscope, compass. Max accleration would be 20g
* pressure(and temperature) sensor to measure altitude
* current sensing to see the amount of current going into fuses
* Mosfet must be able to supply 1.2 amps for at least 10milliseconds. Bridge wire resistance is 1.2-1.8 Ohms
* Must be able to run for at least 1 hour continueously
* must be hand solderable. Perferably
* 100Hz sample rate from sensors(except GPS)
* must record data continueously for at least 3min
* 14 parameters to record: *4 characters*:{accl_x, accl_y, accl_z, gyro_x, gyro_y, gyro_z, compass_x, compass_y, compass_z} + *6 characters:*{pressure}+ *3 characters:*{temperature}+ *7 characters*{Longitude, latitude}+*4 characters:*{altitude}
Assuming ascii encoding, 504 bits per string for raw data. Including commas and carriage return, each reading is ~600 bits.
* Total data storage required: 600bits * 60s * 100hz * 3min = 10.8 Mbits = 10800000 bits

## Major components of V1.1 flight computer
* ST Microelectronics H3LIS100DL: 100g 3-axis accelerometer
* ST Microelectronics LSM9DS1: 9 degree-of-freedom Accelerometer, Gyroscope and Magnetometer in 3 axis
* TE Connectivity MS5607: Temperature and pressure sensor
* Sillicon Labs SI4463: 433 Mhz ISM band Telemetry radio transceiver
* Ublox MAX M8Q: GPS module
* Atmel SAMD21J18: Microcontroller 64 pin TQFP package
* Vishay Si7232DN: Dual N-Channel 20 V (D-S) MOSFET for 2 channel pyros
* Molex 2066400001: GNSS Active Patch Antenna with Low-Noise Amplifier
* Winbond w25q64JV: Flash chip 64 Mbytes

# Flight history

This flight computer was launched in July 2021 but was not recovered. Its now very easy to program using platform.io. No need to mess with board files.

However, the flight computer has 4 major issues.
1. The telemetry radio is terrible. The max range is only around 80 meters, as we discovered at the launch site.
2. The flash chip is quite small. It can only record for around 40 minutes at 3-4 readings a second.
3. The flash write speed is slow. It could be a software issue. I could only write 3-4 readings a second.
4. The position of the power connector for battery is in an awkward position, making it difficult to attach the battery

It may be best to start from scratch using a well known processor, such as an ESP32, and a well designed radio module. From the flight, we discovered that the radio has to work flawlessly. Or else, we will loose the rocket. So maximising range and reliablity of the telemetery is vital. An off the shelf radio module as they will likely have all the RF systems optimised. Its quite hard to do it on a custom PCB.

## Software architecture
We use the Arduino development environment to program the rocket flight computer. We use the arduino board files based off the Adafruit ItsyBitsy M0 Express, which uses the G variant of the SAMD21. The flight computer uses the J variant. 

The main buses are as follows:

`wire` is the main I2C bus for the sensors including the:
* ST Microelectronics H3LIS100DL: 100g 3-axis accelerometer
* ST Microelectronics LSM9DS1: 9 degree-of-freedom Accelerometer, Gyroscope and Magnetometer in 3 axis
* TE Connectivity MS5607: Temperature and pressure sensor
* Ublox MAX M8Q: GPS module

`wire1` is connected to a grove connector on the PCB, but not currently connected to anything.

`Serial` is used for printing out debug info via USB to a serial monitor(running on a computer)

`Serial1` is used for a secondary connection to the Ublox MAX M8Q: GPS module

`SPI1` is used to connect the Winbond w25q64JV: Flash chip 64 Mbytes

`SPI` is used to connect to the Sillicon Labs SI4463: 433 Mhz ISM band Telemetry radio transceiver

## How to setup
# Burning the bootloader
1. Install Atmel studio. It can be downloaded from the [atmel site](https://www.microchip.com/mplab/avr-support/atmel-studio-7). Ensure that you download the SMART ARM MCU option like so: 
2. Connect up the flight computer to the J-Link EDU like so. Note the positions and colours of wires. Getting them the wrong way around could cause reverse polarity issues. The usb connector on the flight computer must be connected to the Computer.
3. Open up Atmel Studio and navigate to Tools > Device Programming like so: 
4. Ensure that the device selected is the ATSAMD21J18A. The default name may be a very similar looking name so make sure you don't mix it up. Click apply.: 
5. Now navigate to the `Memories` tab. You will now burn the custom Arduino boot loader into SAMD21 on the flight computer with Atmel Studio. The bootloader is found in the latest releases by adafruit: https://github.com/adafruit/uf2-samdx1/releases/. Look for the bootloader for the `itsybitsy_m0`. We can use the same bootloader as the Itsybitsy M0 from adafruit. Download the bootloader to your computer and select that file.

 Click the `Program` button once selected the right bootloader: 

Ideally, once the Arduino bootloader is uploaded, the Segger debugger will not be necessary anymore; All future programming can be done with the Arduino IDE.

# Using Platform.io to program the flight computer.
We use Platform.io to program the flight computer as its much more conventient than using the Arduino environment. The platform.ini file captures all the dependencies(libraries, board files) and automatically downloads them. It even downloads the complilers all in the background, so its a simple matter of a single click on the`upload` button to compile and upload to the flight computer.

### Project code
There are 4 pieces of code that are required.
1. [main_code](main_code/). This is the code that flies on the rocket flight computer. It polls all the sensors(GPS, Accelrometers, barometer) and logs them to the SPI flash chip 3-4 times a second. It runs FreeRTOS for scheduling. 
2. [ground_station_receiver](Software/Arduino%20code/ground_station_receiver/). This is the code that runs on the ground station. It will receive packets from the rocket flight computer, and print out the location of the flight computer(longitude, latitude, altitude) and the received signal strength.
3. [spi_flash_dumper](Software/Arduino%20code/spi_flash_dumper/). The flash dumper must be run on the flight computer after the launch. It will dump all the contents of the flash chip, which has stored all the flight data. The format will be in a csv format. The fields in each line will be in the following format:
```
gps_unix_time, gps_millisecond, timestamp, longitude, latitude, altitude, temperature, pressure, h3lis_gyro[0], h3lis_gyro[1], h3lis_gyro[2], h3lis_accelerometer[0], h3lis_accelerometer[1], h3lis_accelerometer[2], lsm9d_gyro[0], lsm9d_gyro[1], lsm9d_gyro[2], lsm9d_accel[0], lsm9d_accel[1], lsm9d_accel[2], lsm9d_mag[0], lsm9d_mag[1], lsm9d_mag[2]
```
4. [spi_flash_deleter](Software/Arduino%20code/spi_flash_deleter/). This program must be run to delete all the contents of the spi flash chip. After a flight, there is a good chance that the flash chip will be full, so delete all contents by running this code on there. Note, the user will have to type in `OK` into the serial terminal inorder for the erase to happen.

### How to upload to flight computer.
To get platform.io, install [Visual Studio code](https://code.visualstudio.com/). Then get the [platform.io](https://platformio.org/install) plugin. Then open the flight computer project you want to use. It should look like in the picture below. Hit the upload button as shown in the picture below to compile and upload to the flight computer. Also, ensure your computer in connected to the device via a USB cable. If all fails, try uploading the boot loader again as described in the [Burning the bootloader](#burning-the-bootloader) section.

# Using Arduino to program(depreciated)
This was the old way of programming the flight computer, but its no longer used. Use the method described in the [Using Platform.io to program the flight computer](#using-platformio-to-program-the-flight-computer) section.
1. Install the Arduino IDE
2. Install Arduino support for the SAMD series of microcontrollers. To do so, go to file > preferences and add `https://adafruit.github.io/arduino-board-index/package_adafruit_index.json` to Additional Board Manager Urls like so: 
3. Then go to Tools > Boards > Boards Manager like so:
4. Then install the SAMD core by searching for Arduino SAMD Boards (32-bits Arm Cortex-M0+) like so: 
5. Then install the Boards support for Adafruit SAMD boards, which our Flight computer is based off. Install version 1.5.9. Put in `Adafruit SAMD Boards` into the search bar.
6. Find out where your newly downloaded board files are found by going here to the file > preferences. In this case the board files are in `C:\Users\Medad\Documents\ArduinoData`. .
7. Now you will have to replace these board files with our own custom board files. Go to the directory found in the previous step and navigate to`ArduinoData\packages\adafruit\hardware\samd` where you will find a folder like `1.5.9`. Now you need to delete this folder, and replace it with our custom folder of board files that can be found in this repo: `Project-Mach-1\Flight computer\Software\Custom board files for flight computer\1.5.9`.
8. Now restart Arduino IDE so that it can update the board file location.
9. Now select the rocket flight computer as the board to use, like so in the picture: 
10. Now select the upload and serial port by going to Tools > Port:
11. Now run the i2c scanner program in `Project-Mach-1\Flight computer\Software\Arduino code\i2c_scanner` on the arduino editor. You will see data on the serial port like this: 

## How to run the main program.
Assuming you have completed the previous steps, navigate to `Project-Mach-1\Flight computer\Software\Arduino code\main_flight_computer_code` and run `main_flight_computer_code.ino` on the Arduino editor. This is where we will be doing further updates to the main project. Note how we directly add the library files into this project. These can be seen in the tabs at the top of the editor: 

The reason why we do this is the stock libraries downloaded directly from Arduino often have minor bugs which we have to fix. Therefore, we make a copy of the library files and load them directly into this project.

## libraries directory
All our libraries are kept here: `Project-Mach-1/tree/master/Flight%20computer/Software/Arduino%20code/libraries`

## IC information

## Diagnositics from the SI4463 chip we use
```
Get Device Info:

Revision: 11
Part: Si4463
Part Build: 0
Id: F
Customer: 0
ROM_ID: 3  (3 = revB1B, 6 = revC2A)
Rev External: 3
Rev Branch: 0
Rev Internal: F
Patch: 0
Func: 1
Radio Temperature: 27.88 deg C
Radio Voltage: 3.29 Volts
```

### Diagnostics of Flash chip
```
Initialising..........
Chip Diagnostics initiated.

No Chip size defined by user. Checking library support.
Chip identified. This chip is fully supported by the library.

SPIMemory Library version: 3.3.0

JEDEC ID: 0xEF7017
Man ID: 0xEF
Memory ID: 0x70
Capacity: 8388608
Max Pages: 32768
Unique ID: 114518745233664, 0x688C52A779213900
-----------------------------------------------------------------------------------------------------------------------------
							Testing library code
-----------------------------------------------------------------------------------------------------------------------------
			Function		Test result			     Runtime
-----------------------------------------------------------------------------------------------------------------------------
			Power Down		   PASS				      53 us
			Power Up		   PASS				      45 us

			Erase Chip		   PASS				      13.618 s
			Erase 72KB		   PASS				      214.66 ms
			Erase 64KB		   PASS				      163.17 ms
			Erase 32KB		   PASS				      119.84 ms
			Erase 4KB		   PASS				      39.14 ms
-----------------------------------------------------------------------------------------------------------------------------
			Data type		I/O Result	      Write time	      Read time
-----------------------------------------------------------------------------------------------------------------------------
			Byte			   PASS			108 us			48 us
			Char			   PASS			120 us			46 us
			Word			   PASS			124 us			48 us
			Short			   PASS			126 us			52 us
			ULong			   PASS			140 us			58 us
			Long			   PASS			128 us			52 us
			Float			   PASS			140 us			54 us
			Struct			   PASS			282 us			94 us
			Byte Array		   PASS			2.07 ms			458 us
			String			   PASS			408 us			164 us
-----------------------------------------------------------------------------------------------------------------------------

```

### Radio working
Image shows the view on SDR sharp when transmitting, and the RX data on a second flight computer. Transmissions done on the first one.

## Current progress
* 25/9/19: The circuit board design files have been sent for manufacturing. Renders are as shown below.

## TODO
* build a base station
* build the rocket
* write all driver code for rocket flight computer(consider using FreeRTOS)
* assemble all flight computer PCBs by soldering
* Test all functions
* Launch!

## License

Hardware is Licensed under CERN OHL v.1.2 or later https://www.ohwr.org/documents/294 No warranty is provided for this documentation implied or otherwise.

Software is licensed under MIT License.

MIT License

Copyright (c) 2018 Imperial College Space Society

Permission is hereby granted, free of charge, to any person obtaining a copy of this software and associated documentation files (the "Software"), to deal in the Software without restriction, including without limitation the rights to use, copy, modify, merge, publish, distribute, sublicense, and/or sell copies of the Software, and to permit persons to whom the Software is furnished to do so, subject to the following conditions:

The above copyright notice and this permission notice shall be included in all copies or substantial portions of the Software.

THE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY, FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER DEALINGS IN THE SOFTWARE.

## KiCad design Flight computer/Hardware/circuit board design v1.1/circuit board design.kicad_pcb

File Flight computer/README.md:

# Project-Mach-1
# **Flight Computer**

## Rocket flight computer requirements:
* flexible for two stage or one stage rocket
* must have buzzer
* must have flashing LEDs to help with recovery on the ground
* must have usb programmer and possibly for accessing stored data
* 3 mosfets for rocket trigger, parachute triggering, spare
* rocket to ground telemetry link
* GPS for tracking and recovery
* runs at 3.3V logic levels(CMOS)
* 9 dof acclermoeter, gyroscope, compass. Max accleration would be 20g
* pressure(and temperature) sensor to measure altitude
* current sensing to see the amount of current going into fuses
* Mosfet must be able to supply 1.2 amps for at least 10milliseconds. Bridge wire resistance is 1.2-1.8 Ohms
* Must be able to run for at least 1 hour continueously
* must be hand solderable. Perferably
* 100Hz sample rate from sensors(except GPS)
* must record data continueously for at least 3min
* 14 parameters to record: *4 characters*:{accl_x, accl_y, accl_z, gyro_x, gyro_y, gyro_z, compass_x, compass_y, compass_z} + *6 characters:*{pressure}+ *3 characters:*{temperature}+ *7 characters*{Longitude, latitude}+*4 characters:*{altitude}
Assuming ascii encoding, 504 bits per string for raw data. Including commas and carriage return, each reading is ~600 bits.
* Total data storage required: 600bits * 60s * 100hz * 3min = 10.8 Mbits = 10800000 bits

## Major components of V1.1 flight computer
* ST Microelectronics H3LIS100DL: 100g 3-axis accelerometer
* ST Microelectronics LSM9DS1: 9 degree-of-freedom Accelerometer, Gyroscope and Magnetometer in 3 axis
* TE Connectivity MS5607: Temperature and pressure sensor
* Sillicon Labs SI4463: 433 Mhz ISM band Telemetry radio transceiver
* Ublox MAX M8Q: GPS module
* Atmel SAMD21J18: Microcontroller 64 pin TQFP package
* Vishay Si7232DN: Dual N-Channel 20 V (D-S) MOSFET for 2 channel pyros
* Molex 2066400001: GNSS Active Patch Antenna with Low-Noise Amplifier
* Winbond w25q64JV: Flash chip 64 Mbytes

Parts:
C13, C18: 10uF; C_0603_1608Metric
C14, C15, C16, C17, C25: 100nF; C_0603_1608Metric
C24: 10nF; C_0603_1608Metric
C77: 220nF; C_0603_1608Metric
R4, R8: 4.7K; R_0603_1608Metric
U1: LSM9DS1; LGA-24L_3x3.5mm_P0.43mm
U5: H3LIS100DL; TFLGA-16_3x3mm
U8: MS5607-02BA; LGA-8_3x5mm_P1.25mm

Connections:
+3V3: C13.2, C14.2, C15.1, C16.1, C17.1, C18.1, C77.1, R4.1, R8.1, U1.1 (VDDIO), U1.3 (VDDIO), U1.5 (SDO_A/G), U1.6 (SDO_M), U1.7 (CS_A/G), U1.8 (CS_M), U1.22 (VDD), U1.23 (VDD), U5.1 (VDD_IO), U5.7 (SDO/SA0), U5.8 (CS), U5.14 (VDD), U5.15 (VDD), U8.1 (VDD), U8.2 (PS); also elsewhere on the board
/gps/GPS_SCL: R8.2, U1.2 (SCL/SPC), U5.4 (SCL/SPC), U8.8 (SCLK); also elsewhere on the board
/gps/GPS_SDA: R4.2, U1.4 (SDA/SDI/SDO), U5.6 (SDA/SDI/SDO), U8.7 (SDI/SDA); also elsewhere on the board
/sensors/ACCL_RDY: U1.11 (INT1_A/G); also elsewhere on the board
/sensors/GYRO_RDY: U1.12 (INT2_A/G); also elsewhere on the board
/sensors/H_ACCL_INT1: U5.11 (INT1); also elsewhere on the board
/sensors/H_ACCL_INT2: U5.9 (INT2); also elsewhere on the board
/sensors/MAG_RDY: U1.9 (DRDY_M); also elsewhere on the board
GND: C13.1, C14.1, C15.2, C16.2, C17.2, C18.2, C24.2, C25.2, C77.2, U1.14 (RES), U1.15 (RES), U1.16 (RES), U1.17 (RES), U1.18 (RES), U1.19 (GND), U1.20 (GND), U5.5 (GND), U5.10 (GND), U5.12 (GND), U5.13 (GND), U5.16 (GND), U8.3 (GND), U8.4 (CSB), U8.5 (CSB); also elsewhere on the board
unnamed: C24.1, U1.21 (CAP)
unnamed: C25.1, U1.24 (C1)

Notes on the sheet:
Power supply decoupling capacitors (100 nF ceramic, 10 μF aluminum) should be placed as near as possible to pin 14 of the device (common design practice).
The slave address(SAD) is dress 0011001b. SA0 is connected to voltage supply.
Power supply decoupling capacitors (100 nF ceramic,10 μF Al) should be placed as near as possible to the supply pin of the device (common design practice).
Capacitor C1 (100 nF) should be a capacitor with low ESR value and should be placed as near as possible to the C1 pin.
C24(10nF) must guarantee 1 nF value under 11 V bias condition
The slave address for accl/gyro is 11010111b(D7h) for Read and 11010110b (D6h) for Write.
The slave address for mag is 00111101b (3Dh) for Read and 00111100b (3Ch) for Write.

Parts:
C8: 10nF; C_0402_1005Metric
C11: 100nF; C_0603_1608Metric
C12: 10uF; C_0603_1608Metric
J6: Conn_Coaxial; U.FL_Hirose_U.FL-R-SMT-1_Vertical
L2: 27nH; R_0402_1005Metric
R2: 10 Ohm; R_0402_1005Metric

Connections:
+3V3: C11.1, C12.1; also elsewhere on the board
GND: C8.2, C11.2, C12.2, J6.2 (Ext); also elsewhere on the board
unnamed: C8.1, L2.1, R2.1
unnamed 63: J6.1 (In), L2.2; also elsewhere on the board
unnamed 66: R2.2; also elsewhere on the board

Notes on the sheet:
http://www.explorelabs.com/blog/designing-a-gps-receiver/#ref-ublox-datasheet Important info on why we use the components
Connected to active antenna, likely 2066400001 Molex active antenna. UFL connector
Layout according to MAX-8 / MAX-M8, Hardware Integration Manual, Section 2.4.2 Antenna design with active antenna.

Parts:
ANT1: Yageo434
C9, C19: 270pF; C_0402_1005Metric
C10: NF; C_0402_1005Metric
C20: 10nF; C_0603_1608Metric
C21: 33nF; C_0603_1608Metric
C22: 1uF; C_0603_1608Metric
C23: 100nF; C_0603_1608Metric
J7: Conn_Coaxial; U.FL_Hirose_U.FL-R-SMT-1_Vertical
L3: 0R; L_0402_1005Metric
L8: 220nH; L_0603_1608Metric
R7: NF; R_0402_1005Metric
U2: 0433BM41A0019E; BALUN_0433BM41A0019E
U3: Si4463; QFN-20-1EP_4x4mm_P0.5mm_EP2.6x2.6mm_ThermalVias
X1: TM-32.000-AF3-33-S-Oscillator; Crystal_SMD_2520-4Pin_2.5x2.0mm

Connections:
+3V3: C19.1, C21.2, C22.1, C23.1, L8.2, U3.6 (VDD), U3.8 (VDD), X1.4 (Vcc); also elsewhere on the board
/MCU/MCU_MISO1: U3.13 (SDO); also elsewhere on the board
/MCU/MCU_MOSI1: U3.14 (SDI); also elsewhere on the board
/MCU/MCU_NSEL1: U3.15 (~SEL); also elsewhere on the board
/MCU/MCU_PA12: U3.10 (GPIO1); also elsewhere on the board
/MCU/MCU_PA13: U3.9 (GPIO0); also elsewhere on the board
/MCU/MCU_PB10: U3.11 (~IRQ); also elsewhere on the board
/MCU/MCU_PB11: U3.1 (SDN); also elsewhere on the board
/MCU/MCU_SCLK1: U3.12 (SCLK); also elsewhere on the board
GND: C10.2, C19.2, C21.1, C22.2, C23.2, J7.2 (Ext), U2.1 (GND), U2.3 (GND), U2.4 (GND), U2.5 (GND), U3.18 (GND), U3.21 (GND), X1.2 (GND); also elsewhere on the board
unnamed: ANT1.1 (RF_IN), C10.1, L3.1
unnamed: C9.1, L3.2, R7.1
unnamed: C9.2, U2.2 (ANT)
unnamed: C20.1, U3.17 (XIN)
unnamed: C20.2, X1.3 (OUT)
unnamed: J7.1 (In), R7.2
unnamed: L8.1, U2.6 (TX), U3.4 (TX)
unnamed: U2.7 (RXN), U3.3 (RXn)
unnamed: U2.8 (RXP), U3.2 (RXp)

Notes on the sheet:
TX Bias
Arranged according to Silabs AN904
Antenna matching options

Parts:
C34: 10nF; C_0603_1608Metric
C35, C36: 1uF; C_0603_1608Metric
D3: DFLS130L; D_PowerDI-123
J2: USB_B_Micro; USB_Micro-B_Molex-105017-0001
J4: Conn_01x02; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
R28, R29: 100K; R_0603_1608Metric
U9: STF202-22T1G; TSOP-6_1.65x3.05mm_P0.95mm
U14: MAX40200AUK; SOT-23-5
U15: LD3985M33R_TSOT23; TSOT-23-5

Connections:
+3V3: C36.1, U15.5 (VOUT); also elsewhere on the board
/MCU/MCU_PB08: R28.2, R29.1; also elsewhere on the board
/MCU/USB_DM: U9.3 (D(IN)); also elsewhere on the board
/power_supply/USB_DM: U9.2 (D(IN)); also elsewhere on the board
GND: C34.2, C35.2, C36.2, J2.5 (GND), J2.6 (Shield), J4.2, R29.2, U9.6 (GND), U14.2 (GND), U15.2 (GND); also elsewhere on the board
unnamed: C34.1, U15.4 (BYP)
unnamed: C35.1, D3.1 (K), U14.5 (OUT), U15.1 (VIN), U15.3 (INH)
unnamed: J2.2 (D-), U9.5 (D(OUT))
unnamed: J2.3 (D+), U9.4 (D(OUT))
VBUS: D3.2 (A), J2.1 (VBUS), U9.1 (VBUS)
Vdrive: J4.1, R28.1, U14.1 (VDD), U14.3 (EN); also elsewhere on the board

Notes on the sheet:
1A Ideal Diode with Ultra-Low Voltage Drop. 43mV drop at 500mA draw
May have to increase the smoothing caps to 10uF for stronger effect.
3.6V-4.2V Li-po input. Needs to be regulated down to 3.3V cmos
Ultra low drop out voltage regulator. 140mV drop at max current of 150mA.
The maximum possible voltage drop(from 3.6V input) due to diode and LDO regulator is 173mV, leaving plenty of leeway to bring it down to 3.3V CMOS level.

Parts:
J3: Screw_Terminal_01x04; TerminalBlock_TE_282834-4_1x04_P2.54mm_Horizontal
R3, R13: 3.3K; R_0603_1608Metric
R5, R15: 120K; R_0603_1608Metric
R6, R16: 27K; R_0603_1608Metric
U6: Si7232DN; Vishay_PowerPAK_1212-8_Dual

Connections:
/MCU/MCU_PA04: R5.1, R6.1; also elsewhere on the board
/MCU/MCU_PA05: R15.1, R16.1; also elsewhere on the board
/pyro_driver/FET_A: J3.4, R5.2, U6.6 (D1)
/pyro_driver/FET_B: J3.2, R15.2, U6.5 (D2)
/pyro_driver/FIRE_A: R3.1, U6.2 (G1); also elsewhere on the board
/pyro_driver/FIRE_B: R13.1, U6.4 (G2); also elsewhere on the board
GND: R3.2, R6.2, R13.2, R16.2, U6.1 (S1), U6.3 (S2); also elsewhere on the board
Vdrive: J3.1, J3.3; also elsewhere on the board

Notes on the sheet:
Goes to a Double Pole Single Throw switch

Parts:
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C1, C2, C5, C92: 10uF; C_0603_1608Metric
C3, C4, C6, C7, C89, C91, C93: 100nF; C_0603_1608Metric
C86, C88: 15pF; C_0603_1608Metric
C90: 1uF; C_0603_1608Metric
D1: RED_LED; LED_0603_1608Metric
D2: BLUE_LED; LED_0603_1608Metric
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J1: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
L1: L_Core_Ferrite; L_0603_1608Metric
R1, R12, R25, R26: 1.6K; R_0603_1608Metric
U7: ATSAMD21J18A-AU; TQFP-64_10x10mm_P0.5mm
U11: W25Q64JVSSIM; SOIC-8_5.23x5.23mm_P1.27mm
Y3: 16MHz; Crystal_SMD_2520-4Pin_2.5x2.0mm

Connections:
+3V3: C1.1, C3.1, C5.1, C6.1, C7.1, C92.1, C93.1, J1.3, L1.1, R1.1, R12.1, U7.21 (VDDIO), U7.34 (VDDIO), U7.48 (VDDIO), U7.56 (VDDIN), U11.3 (IO_2), U11.7 (IO_3), U11.8 (VCC); also elsewhere on the board
/MCU/BUZZER: BZ1.1 (-), U7.1 (PA00)
/MCU/GPS_RXD0: U7.36 (PA17); also elsewhere on the board
/MCU/LED_BLUE: R26.2, U7.50 (PB23)
/MCU/LED_RED: R25.2, U7.49 (PB22)
/MCU/MCU_MISO1: U7.27 (PB14); also elsewhere on the board
/MCU/MCU_MISO4: U7.61 (PB00), U11.2 (IO_1)
/MCU/MCU_MOSI1: U7.25 (PB12); also elsewhere on the board
/MCU/MCU_MOSI4: U7.63 (PB02), U11.5 (IO_0)
/MCU/MCU_NSEL1: U7.28 (PB15); also elsewhere on the board
/MCU/MCU_NSEL4: U7.62 (PB01), U11.1 (CS_N)
/MCU/MCU_PA04: U7.13 (PA04); also elsewhere on the board
/MCU/MCU_PA05: U7.14 (PA05); also elsewhere on the board
/MCU/MCU_PA12: U7.29 (PA12); also elsewhere on the board
/MCU/MCU_PA13: U7.30 (PA13); also elsewhere on the board
/MCU/MCU_PB08: U7.11 (PB08); also elsewhere on the board
/MCU/MCU_PB10: U7.23 (PB10); also elsewhere on the board
/MCU/MCU_PB11: U7.24 (PB11); also elsewhere on the board
/MCU/MCU_SCLK1: U7.26 (PB13); also elsewhere on the board
/MCU/MCU_SCLK4: U7.64 (PB03), U11.6 (CLK)
/MCU/SCL_PA09: U7.18 (PA09); also elsewhere on the board
/MCU/SDA_PA08: U7.17 (PA08); also elsewhere on the board
/MCU/SWCLK: J1.1, R1.2, U7.57 (PA30)
/MCU/SWDIO: J1.2, U7.58 (PA31)
/MCU/USB_DM: U7.45 (PA24); also elsewhere on the board
/MCU/XIN: C86.1, U7.31 (PA14), Y3.1
/MCU/XOUT: C88.1, U7.32 (PA15), Y3.3
/gps/GPS_1PPS: U7.3 (PA02); also elsewhere on the board
/gps/GPS_NRES: U7.4 (PA03); also elsewhere on the board
/gps/GPS_NSAFEBOOT: U7.2 (PA01); also elsewhere on the board
/gps/GPS_RXD: U7.35 (PA16); also elsewhere on the board
/gps/GPS_SCL: U7.44 (PA23); also elsewhere on the board
/gps/GPS_SDA: U7.43 (PA22); also elsewhere on the board
/power_supply/USB_DM: U7.46 (PA25); also elsewhere on the board
/pyro_driver/FIRE_A: U7.19 (PA10); also elsewhere on the board
/pyro_driver/FIRE_B: U7.20 (PA11); also elsewhere on the board
/sensors/ACCL_RDY: U7.38 (PA19); also elsewhere on the board
/sensors/GYRO_RDY: U7.37 (PA18); also elsewhere on the board
/sensors/H_ACCL_INT1: U7.41 (PA20); also elsewhere on the board
/sensors/H_ACCL_INT2: U7.42 (PA21); also elsewhere on the board
/sensors/MAG_RDY: U7.40 (PB17); also elsewhere on the board
GND: BZ1.2 (+), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C86.2, C88.2, C89.2, C90.2, C91.2, C92.2, C93.2, D1.1 (K), D2.1 (K), H1.1, H2.1, H3.1, H4.1, J1.4, U7.7 (GNDANA), U7.22 (GND), U7.33 (GND), U7.47 (GND), U7.54 (GND), U11.4 (GND), Y3.2, Y3.4; also elsewhere on the board
unnamed: C2.1, C4.1, L1.2, U7.8 (VDDANA)
unnamed: C89.1, J1.5, R12.2, U7.52 (~RESET)
unnamed: C90.1, C91.1, U7.53 (VDDCORE)
unnamed: D1.2 (A), R25.1
unnamed: D2.2 (A), R26.1

Notes on the sheet:
Programming interface
SPI flash chip
Buzzer
Two indicator LEDs
Mechanical mounting holes
